Commit message: code

File: urdf/widowx.urdf (robot description, URDF)
Before this commit: robot widowx_arm, 11 links, 10 joints
Joints:
- joint joint_4: origin xyz=0 0 0.14203 rpy=0 1.571 0 -> xyz=0 0 0.14203 rpy=0 0 0
